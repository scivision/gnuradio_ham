options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frequency (Hz)
    orient: Qt.Horizontal
    start: 50e6
    step: '1'
    stop: 2500e6
    value: 100.1e6
  states: {}
- name: fc
  id: variable
  parameters:
    value: 100.1e6
  states: {state: disabled}
- name: rxgain
  id: variable_qtgui_range
  parameters:
    label: rxgain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: rxgain
  id: variable
  parameters:
    value: '75'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: 50e3
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '50000'
    max_dev: 5e3
    quad_rate: '50000'
    tau: '75e-6'
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: fc
  id: variable_slider
  parameters:
    converver: float_converter
    label: fc
    max: 935e6
    min: 100e6
    num_steps: '1000'
    style: wx.SL_HORIZONTAL
    value: 162.475e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '24'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '160'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: samp_rate
    center_freq0: fc
    clock_rate: 32e6
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: rxgain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_am_demod_cf_0, '0', rational_resampler_xxx_0_0, '0']
- [analog_nbfm_rx_0, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_0_0_0, '0', analog_am_demod_cf_0, '0']
- [rational_resampler_xxx_0_0_0, '0', analog_nbfm_rx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0_0_0, '0']

metadata:
  file_format: 1
