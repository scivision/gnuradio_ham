<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>trx_am</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>addr</value></param>
<param><key>value</key><value>"10.0.0.40"</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>ptt</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>2,1,1,1</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>value</key><value>600000</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>rx_samp_rate/2</value></param>
<param><key>step</key><value>10000</value></param>
<param><key>stop</key><value>1.71e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>value</key><value>51e6</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>rx_samp_rate/2</value></param>
<param><key>step</key><value>10000</value></param>
<param><key>stop</key><value>60e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_samp_rate</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_amp</value></param>
<param><key>value</key><value>.01</value></param>
<param><key>label</key><value>TX amplitude</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.005</value></param>
<param><key>stop</key><value>.25</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>value</key><value>51e6</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>tx_samp_rate/2</value></param>
<param><key>step</key><value>10000</value></param>
<param><key>stop</key><value>60e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx_samp_rate</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0</value></param>
<param><key>attack_rate</key><value>1e-3</value></param>
<param><key>decay_rate</key><value>1e-2</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65535</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_am_demod_cf</key>
<param><key>id</key><value>analog_am_demod_cf_0</value></param>
<param><key>audio_decim</key><value>1</value></param>
<param><key>audio_pass</key><value>5000</value></param>
<param><key>audio_stop</key><value>5500</value></param>
<param><key>chan_rate</key><value>rx_samp_rate</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>tx_amp</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>3*tx_amp</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>7.5e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>500</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>rx_samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>3,0,1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1</value></param>
<param><key>bw</key><value>tx_samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>3,1,1,1</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>rx_samp_rate/2000</value></param>
<param><key>interp</key><value>24</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1</value></param>
<param><key>decim</key><value>24</value></param>
<param><key>interp</key><value>tx_samp_rate/2000</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>red_pitaya_sink</key>
<param><key>id</key><value>red_pitaya_sink_0</value></param>
<param><key>addr</key><value>str(addr)</value></param>
<param><key>freq</key><value>tx_freq</value></param>
<param><key>corr</key><value>0</value></param>
<param><key>ptt</key><value>ptt</value></param>
<param><key>port</key><value>1001</value></param>
<param><key>rate</key><value>tx_samp_rate</value></param>
</block>
<block>
<key>red_pitaya_source</key>
<param><key>id</key><value>red_pitaya_source_0</value></param>
<param><key>addr</key><value>str(addr)</value></param>
<param><key>freq</key><value>rx_freq</value></param>
<param><key>corr</key><value>0</value></param>
<param><key>port</key><value>1001</value></param>
<param><key>rate</key><value>rx_samp_rate</value></param>
</block>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_am_demod_cf_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>red_pitaya_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_am_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>audio_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>red_pitaya_source_0</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>red_pitaya_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
