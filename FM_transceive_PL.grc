<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>pl</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>pl</value></param>
<param><key>max</key><value>1</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>ptt</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>label</key><value></value></param>
<param><key>true</key><value>True</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>r0</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>462.5625e6</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>500e6</value></param>
<param><key>min</key><value>400e6</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rxgain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>50</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>100</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>96000</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>txgain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>10</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>100</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>analog_nbfm_rx_0</value></param>
<param><key>audio_rate</key><value>48000</value></param>
<param><key>max_dev</key><value>2.5e3</value></param>
<param><key>quad_rate</key><value>samp_rate</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_nbfm_tx</key>
<param><key>id</key><value>analog_nbfm_tx_0</value></param>
<param><key>audio_rate</key><value>48000</value></param>
<param><key>max_dev</key><value>2.5e3</value></param>
<param><key>quad_rate</key><value>samp_rate</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0</value></param>
<param><key>alpha</key><value>1e-3</value></param>
<param><key>gate</key><value>True</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>threshold</key><value>-60</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>pl</value></param>
<param><key>freq</key><value>114.8</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>48e3</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>.6</value></param>
<param><key>freq</key><value>1e3</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>48e3</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>ok_to_block</key><value>False</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>ok_to_block</key><value>False</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>10</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>ss</value></param>
<param><key>open</key><value>ptt</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>samp_rate/2</value></param>
<param><key>center_freq0</key><value>r0</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>txgain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>len_tag_name</key><value></value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>bw0</key><value>samp_rate/2</value></param>
<param><key>center_freq0</key><value>r0</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rxgain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>r0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>samp_rate</key><value>48000</value></param>
<param><key>t_scale</key><value>0.01</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>v_scale</key><value>.15</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<connection><source_block_id>analog_nbfm_rx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_tx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0</source_block_id><sink_block_id>analog_nbfm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>ss</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ss</source_block_id><sink_block_id>analog_nbfm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>analog_pwr_squelch_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
