options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: trx_am
    output_language: python
  states: {}

blocks:
- name: addr
  id: variable
  parameters:
    value: '"10.0.0.40"'
  states: {}
- name: ptt
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 2,1,1,1
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: rconst
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2,3]'
    type: calcdist
  states: {}
- name: rx_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    orient: Qt.Horizontal
    start: rx_samp_rate//2
    step: '10000'
    stop: 1.71e6
    value: '600000'
  states: {state: disabled}
- name: rx_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    orient: Qt.Horizontal
    start: rx_samp_rate/2
    step: '10000'
    stop: 60e6
    value: 51e6
  states: {}
- name: rx_samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: tconst
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2,3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: tx_amp
  id: variable_qtgui_range
  parameters:
    label: TX amplitude
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '.25'
    value: '.001'
  states: {}
- name: tx_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    orient: Qt.Horizontal
    start: tx_samp_rate/2
    step: '10000'
    stop: 60e6
    value: 51e6
  states: {}
- name: tx_samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /dev/null
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_amp
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: tconst
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: rconst
    fmax: 25e3
    fmin: '0'
    loop_bw: '1e-3'
    showports: 'True'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: rx_samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 3,0,1,1
    name: QT GUI Plot
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: tx_samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,1,1,1
    name: QT GUI Plot
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    label2: ''
    size: '1024'
    srate: tx_samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    label2: ''
    size: '1024'
    srate: tx_samp_rate
    type: complex
  states: {}
- name: red_pitaya_sink_0
  id: red_pitaya_sink
  parameters:
    addr: str(addr)
    corr: '0'
    freq: tx_freq
    port: '1001'
    ptt: ptt
    rate: tx_samp_rate
  states: {}
- name: red_pitaya_source_0
  id: red_pitaya_source
  parameters:
    addr: str(addr)
    corr: '0'
    freq: rx_freq
    port: '1001'
    rate: rx_samp_rate
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_constellation_modulator_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', red_pitaya_sink_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_constellation_receiver_cb_0, '0', blocks_file_sink_0, '0']
- [digital_constellation_receiver_cb_0, '1', blocks_null_sink_0, '0']
- [digital_constellation_receiver_cb_0, '2', blocks_null_sink_0_0, '0']
- [digital_constellation_receiver_cb_0, '3', blocks_null_sink_0_1, '0']
- [digital_constellation_receiver_cb_0, '4', qtgui_time_sink_x_0_0, '0']
- [red_pitaya_source_0, '0', digital_constellation_receiver_cb_0, '0']
- [red_pitaya_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
