options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: trx_am
    output_language: python
  states: {}

blocks:
- name: addr
  id: variable
  parameters:
    value: '"10.0.0.40"'
  states: {}
- name: ptt
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 2,1,1,1
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: rx_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    orient: Qt.Horizontal
    start: rx_samp_rate//2
    step: '10000'
    stop: 1.71e6
    value: '600000'
  states: {state: disabled}
- name: rx_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    orient: Qt.Horizontal
    start: rx_samp_rate/2
    step: '10000'
    stop: 60e6
    value: 51e6
  states: {}
- name: rx_samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: tx_amp
  id: variable_qtgui_range
  parameters:
    label: TX amplitude
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '.25'
    value: '.001'
  states: {}
- name: tx_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    orient: Qt.Horizontal
    start: tx_samp_rate/2
    step: '10000'
    stop: 60e6
    value: 51e6
  states: {}
- name: tx_samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65535'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: rx_samp_rate
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_amp
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: rx_samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 3,0,1,1
    name: QT GUI Plot
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: tx_samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,1,1,1
    name: QT GUI Plot
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: rx_samp_rate//2000
    interp: '24'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '24'
    interp: tx_samp_rate//2000
    taps: ''
    type: ccc
  states: {}
- name: red_pitaya_sink_0
  id: red_pitaya_sink
  parameters:
    addr: str(addr)
    corr: '0'
    freq: tx_freq
    port: '1001'
    ptt: ptt
    rate: tx_samp_rate
  states: {}
- name: red_pitaya_source_0
  id: red_pitaya_source
  parameters:
    addr: str(addr)
    corr: '0'
    freq: rx_freq
    port: '1001'
    rate: rx_samp_rate
  states: {}

connections:
- [analog_agc2_xx_0, '0', analog_fm_demod_cf_0, '0']
- [analog_fm_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [analog_wfm_tx_0, '0', blocks_multiply_const_vxx_0, '0']
- [audio_source_0, '0', analog_wfm_tx_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', audio_sink_1, '0']
- [rational_resampler_xxx_1, '0', qtgui_freq_sink_x_1, '0']
- [rational_resampler_xxx_1, '0', red_pitaya_sink_0, '0']
- [red_pitaya_source_0, '0', analog_agc2_xx_0, '0']
- [red_pitaya_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
