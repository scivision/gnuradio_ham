options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frequency (Hz)
    orient: Qt.Horizontal
    start: 87.7e6
    step: 100e3
    stop: 108.1e6
    value: 100.1e6
  states: {}
- name: rxgain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: '200000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '40'
    gain: '1'
    high_cutoff_freq: 75e3
    low_cutoff_freq: '-75e3'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: 25e3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '24'
    taps: ''
    type: fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: samp_rate
    center_freq0: fc
    clock_rate: 32e6
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: rxgain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [band_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '0', band_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
