options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: trx_ssb
    output_language: python
  states: {}

blocks:
- name: addr
  id: variable
  parameters:
    value: '"10.0.0.40"'
  states: {}
- name: band
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 2,0,1,1
    label0: lsb
    label1: usb
    num_opts: '2'
    option1: '[300, 3000]'
    type: raw
    value: '[-3000, -300]'
  states: {}
- name: ptt
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 2,1,1,1
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: rx_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    orient: Qt.Horizontal
    start: rx_samp_rate/2
    step: '1000'
    stop: '60000000'
    value: '600000'
  states: {}
- name: rx_samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: tx_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    orient: Qt.Horizontal
    start: tx_samp_rate/2
    step: '1000'
    stop: '60000000'
    value: '600000'
  states: {}
- name: tx_samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-2'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: float
  states: {state: disabled}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.'
    type: float
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.complex_band_pass(1, rx_samp_rate, band[0], band[1], 100, firdes.WIN_HAMMING )
    type: ccc
  states: {}
- name: fft_filter_xxx_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.complex_band_pass(1, tx_samp_rate, band[0], band[1], 100, firdes.WIN_HAMMING )
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: rx_samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0,1,1
    name: QT GUI Plot
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: tx_samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,1,1,1
    name: QT GUI Plot
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: rx_samp_rate//2000
    interp: '24'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '24'
    interp: tx_samp_rate//2000
    taps: ''
    type: fff
  states: {}
- name: red_pitaya_sink_0
  id: red_pitaya_sink
  parameters:
    addr: str(addr)
    corr: '0'
    freq: tx_freq
    port: '1001'
    ptt: ptt
    rate: tx_samp_rate
  states: {}
- name: red_pitaya_source_0
  id: red_pitaya_source
  parameters:
    addr: str(addr)
    corr: '0'
    freq: rx_freq
    port: '1001'
    rate: rx_samp_rate
  states: {}

connections:
- [analog_agc2_xx_0, '0', audio_sink_1, '0']
- [analog_agc_xx_0, '0', audio_sink_1, '0']
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [audio_source_0, '0', rational_resampler_xxx_1, '0']
- [blocks_complex_to_real_0, '0', rational_resampler_xxx_0, '0']
- [blocks_float_to_complex_0, '0', fft_filter_xxx_0_0, '0']
- [fft_filter_xxx_0, '0', blocks_complex_to_real_0, '0']
- [fft_filter_xxx_0_0, '0', qtgui_freq_sink_x_1, '0']
- [fft_filter_xxx_0_0, '0', red_pitaya_sink_0, '0']
- [rational_resampler_xxx_0, '0', analog_agc2_xx_0, '0']
- [rational_resampler_xxx_0, '0', analog_agc_xx_0, '0']
- [rational_resampler_xxx_1, '0', blocks_float_to_complex_0, '0']
- [red_pitaya_source_0, '0', fft_filter_xxx_0, '0']
- [red_pitaya_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
